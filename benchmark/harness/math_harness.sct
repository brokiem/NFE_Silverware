LR_ROM 0x00100000 0x00100000
{
    ER_ROM 0x00100000 0x00100000
    {
        *.o (+RO)
    }

    RW_RAM 0x20000000 0x00200000
    {
        *.o (+RW +ZI)
    }
}
